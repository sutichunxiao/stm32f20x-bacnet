# Keil uVision project Project.uvproj, settings and files
target BACnet (ARM-ADS)
  device: STM32F205ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX,USE_STDPERIPH_DRIVER,BACDL_MSTP,MAX_APDU=480,BIG_ENDIAN=0,MAX_TSM_TRANSACTIONS=1,MAX_CHARACTER_STRING_BYTES=64,MAX_OCTET_STRING_BYTES=64,BACAPP_BOOLEAN,BACAPP_REAL,BACAPP_OBJECT_ID,BACAPP_UNSIGNED,BACAPP_ENUMERATED,BACAPP_CHARACTER_STRING,WRITE_PROPERTY
  c include: ..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\User\common;..\User\bacnet;..\User\bacnet\include;..\User\bacnet\object
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: stm32f2xx_it.c main.c
    ../User/common/: config.c usart.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_gpio.c stm32f2xx_usart.c stm32f2xx_rcc.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Readme
    ../User/: readme.txt
  group BACnet
    ../User/bacnet/src/: abort.c apdu.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c dcc.c fifo.c iam.c ihave.c memcopy.c npdu.c rd.c reject.c ringbuf.c rp.c rpm.c whohas.c whois.c wp.c tsm.c address.c
  group BACHandle
    ../User/bacnet/handler/: h_dcc.c h_npdu.c h_rd.c h_rp.c h_rpm.c h_whois.c h_wp.c noserv.c s_iam.c s_ihave.c txbuf.c h_whohas.c s_rp.c h_rp_a.c s_wp.c h_rpm_a.c s_rpm.c
  group BACuser
    ../User/bacnet/: automac.c bacnet.c device.c dlmstp.c timer.c rs485.c
    ../User/bacnet/object/: bo.c bo.h bi.c ai.c ao.c
